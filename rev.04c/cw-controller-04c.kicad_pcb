# Repository prusa3d/CW-CONTROLLER-PCB

File README.md:

# PRUSA CW controller board

KiCad PCB layout

* [Interactive bom](http://htmlpreview.github.io/?https://github.com/prusa3d/CW-CONTROLLER-PCB/blob/master/rev.04c/ibom.html)
* [STEP 3D model](rev.04c/cw-controller-04c.step)

## KiCad design rev.04c/cw-controller-04c.kicad_pcb

Parts:
C1: 220u; c_elec_8x10.5
C2, C4, C5, C9, C14, C15, C18, C19, C22, C23, C25, C29, C31, C33, C38, C39, C40, C41, C51, C63: 100n; C_0603
C3: 10u; C_0603
C6, C10: 1u; C_0603
C7, C11: 22p; C_0603
C8: 220u*; c_elec_8x10.5
C27, C44: 680u; CP_Radial_D8.0mm_P3.50mm
D1: B540C-13-F; SMC_Standard
D2, D8, D9, D10, D11, D21, D22: GRN; LED_0603
D3, D20: SM6T30A; D_SMB
D4, D12, D14, D15, D17, D18, D30: BAV99LT1G; SOT-23
D5: SK310A-TP; DO-214AC
D6, D28, D29, D31: BAT54KFILM; SOD-523-ShortSilk
D7: BAT54KFILM*; SOD-523-ShortSilk
F1, F2: KEYSTONE 3568; Fuse-Keystone-3557-2
J1: USB-micro
J2, J3: faston_4,8mm_0,8mm_12,5mm; faston-hole-m
L2: 100uH; SELF-WE-PD-XXL
L3, L4, L5, L6, L7, L12, L13, L14, L15, L17, L18, L19, L20, L21, L22, L23, L24, L25, L26, L27, L29, L30, L31, L45, L46, L47, L49, L50: BLM18KG121TN1D; R_0603
P1: KPJX-4S-S; KPJX-4S
P2: TBG-5-PW-3P/GN; PhoenixContact_MSTBVA_2,5_3-G-5,08_1x03_P5.08mm_Vertical
P3, P11, P12, P15, P16, P21: MP*; MountingHole_3.2mm_M3_ISO14580_Pad
P4, P17: 70543-0001; Pin_1x02-XL
P5: DS1021-2*3SF1-1; PinHeader_2x03_P2.54mm_Vertical
P6, P7: 302-S101; IDC_Header_Straight_10pins
P9, P10: 70543-0003; Pin_1x04-XL
P13: 70543-0002; Pin_1x04-XL
P14: 70543-0009; Pin_1x10-XL
Q1, Q3, Q4, Q5, Q6: MMBF170; SOT-23
Q2: PSMN1R8-40YLC; SOT-669_LFPAK_alternate-numbers
R1, R3, R12, R21, R41, R42, R46, R48, R75: 100R; R_0603
R2, R10, R11, R16, R44, R45, R49, R50, R73, R74: 1k8; R_0603
R4, R5: 22R; R_0603
R6, R27, R39, R40, R47: 100k; R_0603
R7, R13, R15, R25, R31, R33, R38, R43, R76, R77, R78, R79: 10k; R_0603
R8, R9, R23, R24: 1k; R_0603
R14: 82k; R_0603
R17: 33k; R_0603
R18: 1M; R_0603
R72: 0R*; R_0603
S1: TACTA-64N-F; TACT-90
U1: LM2576; TO-263-5-heatsink
U2: ATmega32U4; QFN-44-1EP_7x7mm_Pitch0.5mm
U5: MCP23S17-E/SS; SSOP-28_5.3x10.2mm_Pitch0.65mm
U6: 74LVC1G08GW.125; SOT-353_SC-70-5
U7: 74HCT4052PW.118; TSSOP-16_4.4x5mm_P0.65mm
Y1: LFXTAL035264REEL; Crystal-3.2x2.5mm

Connections:
24VDC: C1.1, C4.2, C19.2, C22.2, D20.1 (K), D21.2 (A), D22.2 (A), F1.1, L26.2, L27.2, U1.1 (Vin); also elsewhere on the board
+5V: C18.2, C23.1, C25.1, C27.1, C44.1, C63.2, D4.2 (K), D6.1 (K), D7.1 (K), D12.2 (K), D14.2 (K), D15.2 (K), D18.2 (K), D30.2 (K), L2.2, L22.1, L24.2, L29.1, L50.2, P5.2, R8.1, R14.2, R15.2, R17.2, R23.1, R24.1, R25.1, R31.1, R43.1, R44.2, R45.2, R74.2, R76.1, R77.1, R78.2, R79.2, U1.4 (feedback), U5.9 (VCC), U6.5 (VCC), U7.16 (Vcc); also elsewhere on the board
+24V-HEATER: C5.2, C8.1, D3.1 (K), D5.1 (K), F2.1, P2.1, R7.1
/4channel-LED-PWR/ENABLE: R9.2, U6.4; also elsewhere on the board
/4channel-LED-PWR/LED1+: P14.2; also elsewhere on the board
/4channel-LED-PWR/LED1-: P14.1; also elsewhere on the board
/4channel-LED-PWR/LED2+: P14.4; also elsewhere on the board
/4channel-LED-PWR/LED2-: P14.3; also elsewhere on the board
/4channel-LED-PWR/LED3+: P14.8; also elsewhere on the board
/4channel-LED-PWR/LED3-: P14.7; also elsewhere on the board
/4channel-LED-PWR/LED4+: P14.10; also elsewhere on the board
/4channel-LED-PWR/LED4-: P14.9; also elsewhere on the board
/4channel-LED-PWR/PWM: R1.1; also elsewhere on the board
/D+: R5.2, U2.4 (D+)
/D-: R4.1, U2.3 (D-)
/RESET: C38.1, D6.2 (A), P5.5, R15.1, R72.2, S1.1, U2.13 (RESET)
/VBUS: C2.2, C3.2, D7.2 (A), L6.2, U2.7 (VBUS)
AnalogSwA: U5.2 (GPB1), U7.10 (A)
AnalogSwB: U5.1 (GPB0), U7.9 (B)
CS-MCP: U2.28 ((ADC11/PCINT4)PB4), U5.11 (~CS)
CSN-DRV: U2.1 ((INT6/AIN0)PE6); also elsewhere on the board
DIR: U5.26 (GPA5); also elsewhere on the board
Diag: U5.25 (GPA4); also elsewhere on the board
EN: U5.24 (GPA3); also elsewhere on the board
END1: C31.1, D17.3 (common), R12.2, R46.1, U5.23 (GPA2)
END2: C15.2, D12.3 (common), R43.2, R48.2, U5.22 (GPA1)
FAN1: R42.1, U5.4 (GPB3)
FAN1-PWM: R75.1, U2.32 ((ICP3/CLK0/OC4A)PC7)
FAN1-TACH: R50.1, U2.20 ((RXD/INT2)PD2)
FAN2: R41.1, U5.5 (GPB4)
FAN2-PWM: R21.1, U2.12 ((OC0A/OC1C/~RTS~/PCINT7)PB7)
FAN2-TACH: R49.1, U2.19 ((SDA/INT1)PD1)
FAN3-TACH: R73.1, U2.21 ((TXD/INT3)PD3)
HEATER: R3.1, U5.3 (GPB2)
LCD-4: L5.1, U2.30 ((ADC13/OC1B/OC4B/PCINT13)PB6)
LCD-5: L21.2, U2.36 ((ADC7/TDI)PF7)
LCD-6: L12.1, U2.33 ((~HWB~)PE2)
LCD-7: L23.2, U2.37 ((ADC6/TDO)PF6)
LCD-BEEPER: L3.1, U2.29 ((ADC12/OC1A/~OC4B~/PCINT12)PB5)
LCD-BUTTON: L19.2, U5.21 (GPA0)
LCD-E: L4.1, U2.25 ((ICP2/ADC8)PD4)
LCD-ENC1: L14.1, U2.38 ((ADC5/TMS)PF5)
LCD-ENC2: L15.1, U2.39 ((ADC4/TCK)PF4)
LCD-PWM: L25.2, U2.27 ((T0/OC4D/ADC10)PD7)
LCD-RS: L20.2, U2.26 ((T1/~OC4D~/ADC9)PD6)
MISO: P5.1, U2.11 ((PDO/MISO/PCINT3)PB3), U5.14 (SO); also elsewhere on the board
MOSI: P5.4, U2.10 ((PDI/MOSI/PCINT2)PB2), U5.13 (SI); also elsewhere on the board
unnamed: C6.2, L7.1, U2.24 (AVCC), U2.44 (AVCC)
unnamed: C7.1, R18.2, U2.17 (XTAL1), Y1.1
unnamed: C9.2, U2.42 (AREF)
unnamed: C10.2, U2.6 (UCAP)
unnamed: C11.1, R18.1, U2.16 (XTAL2), Y1.3
unnamed: C14.2, P7.3, R72.1
unnamed: C19.1, L30.1, Q6.3 (D), R33.1
unnamed: C22.1, L31.1, Q5.3 (D), R38.1
unnamed: C39.1, C40.1, L7.2, L22.2, U2.2 (UVCC), U2.14 (VCC), U2.34 (VCC)
unnamed: D1.1 (K), L2.1, U1.2 (OUT)
unnamed: D2.2 (A), R8.2
unnamed: D4.3 (common), R2.1, R16.2
unnamed: D8.1 (K), U2.8 ((SS/PCINT0)PB0)
unnamed: D8.2 (A), R23.2
unnamed: D9.1 (K), U2.22 ((XCK1/~CTS~)PD5)
unnamed: D9.2 (A), R24.2
unnamed: D10.2 (A), R9.1
unnamed: D5.2 (A), D11.1 (K), P2.2, Q2.3 (D)
unnamed: D11.2 (A), R7.2
unnamed: D14.3 (common), D28.2 (A), R45.1, R50.2
unnamed: D15.3 (common), D29.2 (A), R44.1, R49.2
unnamed: D17.2 (K), L29.2, R13.1
unnamed: D18.3 (common), R10.1, R11.2
unnamed: D21.1 (K), R38.2
unnamed: D22.1 (K), R33.2
unnamed: D28.1 (K), P10.3
unnamed: D29.1 (K), P9.3
unnamed: D30.3 (common), D31.2 (A), R73.2, R74.1
unnamed: D31.1 (K), P2.3
unnamed: F1.2, F2.2, J2.1
unnamed: J1.1 (+5V), L6.1
unnamed: J1.2 (D-), R4.2
unnamed: J1.3 (D+), R5.1
unnamed: J3.1, P1.2, P1.4
unnamed: L3.2, P6.10
unnamed: L4.2, P6.8
unnamed: L5.2, P6.6
unnamed: L12.2, P6.4
unnamed: L13.2, P6.2
unnamed: L14.2, P7.8
unnamed: L15.2, P7.6
unnamed: L17.2, P14.6
unnamed: L18.2, P7.2
unnamed: L19.1, P6.9
unnamed: L20.1, P6.7
unnamed: L21.1, P6.5
unnamed: L23.1, P6.3
unnamed: L24.1, P6.1
unnamed: L25.1, P7.1
unnamed: L26.1, P9.2
unnamed: L27.1, P10.2
unnamed: L30.2, P9.1
unnamed: L31.2, P10.1
unnamed: L45.1, P9.4
unnamed: L45.2, Q3.3 (D), R78.1
unnamed: L46.1, P10.4
unnamed: L46.2, Q4.3 (D), R79.1
unnamed: L47.2, P13.3, P17.2
unnamed: L49.1, P4.2
unnamed: L50.1, P13.4
unnamed: P4.1, R12.1, R13.2
unnamed: P13.1, P17.1, R11.1, R14.1
unnamed: P13.2, R48.1
unnamed: P14.5, R16.1, R17.1
unnamed: Q1.1 (G), R46.2, R47.2
unnamed: Q1.3 (D), R31.2, U6.1
unnamed: Q2.1 (G), R3.2, R6.2
unnamed: Q3.1 (G), R21.2, R76.2
unnamed: Q4.1 (G), R75.2, R77.2
unnamed: Q5.1 (G), R40.1, R42.2
unnamed: Q6.1 (G), R39.1, R41.2
unnamed: R25.2, U5.18 (~RESET)
PINDA-THERM: C29.1, R10.2, U7.1 (Y0)
SCK: P5.3, U2.9 ((SCLK/PCINT1)PB1), U5.12 (SCK); also elsewhere on the board
Step: U2.31 ((OC3A/~OC4A~)PC6); also elsewhere on the board
TEMP-LED: C41.1, R2.2, U7.5 (Y1)
THERM-TEMP-MULTIPLEX: C33.2, U2.40 ((ADC1)PF1), U7.3 (Y)
UV-LED: R27.1, U5.27 (GPA6), U6.2
UV-LED-1: U7.11 (X3); also elsewhere on the board
UV-LED-2: U7.12 (X0); also elsewhere on the board
UV-LED-3: U7.14 (X1); also elsewhere on the board
UV-LED-4: U7.15 (X2); also elsewhere on the board
UV-LED-MULTIPLEX: C51.1, U2.41 ((ADC0)PF0), U7.13 (X)
UV-LED-PWM: R1.2, U2.18 ((OC0B/SCL/INT0)PD0)

Notes on the sheet:
Endstops
Fan
Stepper
GPIO
CPU
USB
ICSP
Power
24V
Mounting Holes
UV-LED
page 2
SPI
(3-gnd 5-vcc)
LCD
Heater
PWM
power_switch
not use
Multiplexer
Changelog ------- rev 0.4c - C56-C59 to 0805 - P13 change to 70543-0002 - F1 to 3A - F2 to 7,5A rev 0.4b - replace BAT54JFILM to BAT54KFILM - use P17 - remove R80 rev 0.4 - R62-R65 change footprint to 0805 -change FAN 1 and FAN 2 connectors to 4 pin (add pwm control) - add P17 connector for thermis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
USE 70543-0002

Parts:
C12, C16, C17, C20, C21, C24, C26, C28, C42: 100n; C_0603
C13: 22n; C_0603
C30: 100u; c_elec_6.3x7.7
C32: 1u; C_0603
C34, C35, C36, C37: 1n; C_0603
C43: 10u; C_0603
L8, L9, L10, L11, L16: BLM18KG121TN1D; R_0603
P8: 70543-0003; Pin_1x04-XL
R26: 10k; R_0603
R28, R29: R22; R_1206
R32: 10R; R_0603
U3: TMC2130-LA; QFN-36-1EP_5x6mm_Pitch0.5mm-GNDpad-0.3mm

Connections:
24VDC: C12.1, C24.1, C26.1, C30.1, U3.16 (VS), U3.31 (VS); also elsewhere on the board
+5V: C42.1, L16.1, R26.1; also elsewhere on the board
+5V-MOT: C16.1, C17.1, C28.1, C43.1, L16.2, R32.1, U3.8 (VCC-IO), U3.26 (VCC), U3.30 (VSA)
CSN-DRV: U3.2 (CSN); also elsewhere on the board
DIR: U3.7 (DIR); also elsewhere on the board
Diag: R26.2, U3.20 (DIAG0), U3.21 (DIAG1); also elsewhere on the board
EN: U3.22 (DRV-ENN); also elsewhere on the board
MISO: U3.5 (SDO); also elsewhere on the board
MOSI: U3.4 (SDI); also elsewhere on the board
unnamed: C12.2, U3.29 (VCP)
unnamed: C13.1, U3.27 (CPO)
unnamed: C13.2, U3.28 (CPI)
unnamed: C20.1, R28.2, U3.33 (BRA)
unnamed: C21.1, R29.2, U3.14 (BRB)
unnamed: C32.2, R32.2, U3.25 (5Vout)
unnamed: C34.2, L8.1, U3.32 (OA2)
unnamed: C35.2, L9.1, U3.34 (OA1)
unnamed: C36.2, L10.1, U3.15 (OB2)
unnamed: C37.2, L11.1, U3.13 (OB1)
unnamed: L8.2, P8.1
unnamed: L9.2, P8.2
unnamed: L10.2, P8.3
unnamed: L11.2, P8.4
SCK: U3.3 (SCK); also elsewhere on the board
Step: U3.6 (STEP); also elsewhere on the board

Schematic: LT3476.sch, CW

Parts:
C45, C46, C48, C49: 1n; C_0603
C47, C53: 100n; C_0603
C50, C54, C55, C60: 100n*; C_0603
C52: 1u; C_0603
C56, C57, C58, C59: 330n; C_0805
C61, C62: 2,2u; C_1206
D23, D24, D25, D26: DFLS140L; D_PowerDI-123
L33, L34, L35, L36, L37, L38, L39, L40: BLM18KG121TN1D; R_0603
L41, L42, L43, L44: 10uH LQH44PN100MP0L; Inductor_Murata-4040
R19, R22, R34, R36: 10k*; R_0603
R20, R30, R35, R37: 0R; R_0603
R51, R52, R53, R54, R55, R56, R57, R58: 47k; R_0603
R59: 21k; R_0603
R60, R61, R66, R67, R68, R69, R70, R71: 1M*; R_0603
R62, R63, R64, R65: 0,1R; R_0805
U4: LT3476; QFN-38-1EP_5x7mm_Pitch0.5mm_VIA

Connections:
24VDC: C56.1, C57.1, C58.1, C59.1, C61.1, C62.1, D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), R62.2, R63.2, R64.2, R65.2, U4.3 (CAP1), U4.4 (CAP2), U4.9 (CAP3), U4.10 (CAP4); also elsewhere on the board
+5V: C52.1, C53.1, R19.2, R22.2, R34.2, R36.2, U4.33 (Vin); also elsewhere on the board
/4channel-LED-PWR/ENABLE: U4.18 (SHDN); also elsewhere on the board
/4channel-LED-PWR/LED1+: L33.1; also elsewhere on the board
/4channel-LED-PWR/LED1-: L37.2; also elsewhere on the board
/4channel-LED-PWR/LED2+: L34.1; also elsewhere on the board
/4channel-LED-PWR/LED2-: L38.2; also elsewhere on the board
/4channel-LED-PWR/LED3+: L35.1; also elsewhere on the board
/4channel-LED-PWR/LED3-: L39.2; also elsewhere on the board
/4channel-LED-PWR/LED4+: L36.1; also elsewhere on the board
/4channel-LED-PWR/LED4-: L40.2; also elsewhere on the board
/4channel-LED-PWR/MP1: C56.2, L37.1, L41.1, R60.1
/4channel-LED-PWR/MP2: C57.2, L38.1, L42.1, R66.1
/4channel-LED-PWR/MP3: C58.2, L39.1, L43.1, R68.1
/4channel-LED-PWR/MP4: C59.2, L40.1, L44.1, R70.1
/4channel-LED-PWR/PWM: R20.1, R30.1, R35.1, R37.1; also elsewhere on the board
unnamed: C45.1, U4.1 (VC1)
unnamed: C46.1, U4.38 (VC2)
unnamed: C47.1, R55.1, R56.1, R57.1, R58.1, U4.7 (REF)
unnamed: C48.1, U4.13 (VC3)
unnamed: C49.1, U4.12 (VC4)
unnamed: D23.2 (A), L41.2, U4.28 (SW1), U4.29 (SW1)
unnamed: D24.2 (A), L42.2, U4.26 (SW2), U4.27 (SW2)
unnamed: D25.2 (A), L43.2, U4.24 (SW3), U4.25 (SW3)
unnamed: D26.2 (A), L44.2, U4.22 (SW4), U4.23 (SW4)
unnamed: L33.2, R62.1, U4.2 (LED1)
unnamed: L34.2, R63.1, U4.5 (LED2)
unnamed: L35.2, R64.1, U4.8 (LED3)
unnamed: L36.2, R65.1, U4.11 (LED4)
unnamed: R19.1, R20.2, U4.16 (PWM4)
unnamed: R22.1, R30.2, U4.17 (PWM3)
unnamed: R34.1, R35.2, U4.34 (PWM2)
unnamed: R36.1, R37.2, U4.35 (PWM1)
unnamed: R51.1, R55.2, U4.37 (VADJ1)
unnamed: R52.1, R56.2, U4.36 (VADJ2)
unnamed: R53.1, R57.2, U4.15 (VADJ3)
unnamed: R54.1, R58.2, U4.14 (VADJ4)
unnamed: R59.1, U4.6 (RT)
UV-LED-1: C50.1, R60.2, R61.1; also elsewhere on the board
UV-LED-2: C54.1, R66.2, R67.1; also elsewhere on the board
UV-LED-3: C55.1, R68.2, R69.1; also elsewhere on the board
UV-LED-4: C60.1, R70.2, R71.1; also elsewhere on the board

Notes on the sheet:
140k - 200kHz 61.9k - 400kHz 21k - 1MHz 16.2k - 1.2 MHz 8.25k - 2MHz
not use
8-24V
1,4-4,2V

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
Board: 4 copper layers, 126.0 x 57.0 mm, 253 parts (0 on the bottom side), 173 nets.

Notices in the files:
rev.04c/LT3476.sch:
http://creativecommons.org/licenses/by-sa/4.0
Licensed under the Attribution-ShareAlike 4.0 International (CC BY-SA 4.0)
